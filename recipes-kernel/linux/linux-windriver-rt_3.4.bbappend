include linux-windriver-xilinx-zynq.inc

TARGET_SUPPORTED_KTYPES += " preempt-rt"
