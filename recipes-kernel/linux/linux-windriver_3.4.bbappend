require linux-windriver-xilinx-zynq.inc
